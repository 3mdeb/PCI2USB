# Repository 3mdeb/PCI2USB

## KiCad design Kicad-Files/PCI2USB.kicad_pcb

Board: 4 copper layers, 21.6 x 79.5 mm, 90 parts (55 on the bottom side), 48 nets.

Parts:
C1, C2, C10, C12, C14, C16, C18, C19, C20, C21, C22, C23, C25, C28, C30, C33, C35, C38, C40, C42, C43, C44, C45, C47, C48, C49, C50, C51, C52: 0.1u; C_0402_1005Metric
C3, C5: 1000pF; C_0402_1005Metric
C4, C8, C11, C17, C27, C41, C46: 22u; C_0805_2012Metric
C6, C7: 18p; C_0402_1005Metric
C9, C13, C15: 100u_6.3V; C_1206_3216Metric
C24, C26, C29, C31, C32, C34, C36, C39, C53, C54: 0.01u; C_0402_1005Metric
C37: NOPOP; C_0402_1005Metric
D1: 4V/6.5V/5A; PJSD0XTS-AU
D2: RED; LED_0603_1608Metric
D3, D4: 6V/9V/5A; PJSD0XTS-AU
D5, D6: GRN; LED_0603_1608Metric
F1: 5A; Fuse_0603_1608Metric
J1: M.2 Edge Connector; M.2_KEY_M_B
J2: USB_9PIN_Internal; PinHeader_2x05_P2.54mm_Vertical_SMD
L1, L2: 90 Ohm 160mA; MCZ1210AH201L2TA0G
L3: 1u; L_Chilisin_BMRx00050515
L4: 220R; L_0603_1608Metric
R1, R2, R9, R10, R15: 10K; R_0402_1005Metric
R3: 1M; R_0402_1005Metric
R4: 9.09K_1%; R_0402_1005Metric
R5, R14: 4.7K; R_0402_1005Metric
R6: 100K_1%; R_0402_1005Metric
R7: 732K_1%; R_0402_1005Metric
R8: 30.9K_1%; R_0402_1005Metric
R11: 1.5K; R_0402_1005Metric
R12, R13: 680R; R_0402_1005Metric
R16: 1.87K_1%; R_0402_1005Metric
R17: 4.99K_1%; R_0402_1005Metric
U1: TUSB7320; TUSB7320RKMT
U2: TPD4EUSB30; USON-10_2.5x1.0mm_P0.5mm
U3: TPS61023DRLR
U4: TPS2560DRC; TPS2560DRCT
U5: TPS74401; TPS74401RGWRM3
Y1: 48Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1.1V: C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C28.1, C29.1, C30.1, C31.1, C33.1, C34.1, C35.1, C36.1, C38.1, C39.1, C46.1, R16.1, U1.A1 (VDD11), U1.A4 (VDD11), U1.A6 (VDD11), U1.A9 (VDD11), U1.A12 (VDD11), U1.A16 (VDD11), U1.A28 (VDD11), U1.A31 (VDD11), U1.A33 (VDD11), U1.A38 (VDD11), U1.A50 (VDD11), U1.B1 (VDD11), U1.B17 (VDD11), U1.B19 (VDD11), U1.B24 (VDD11), U1.B37 (VDD11), U1.B40 (VDD11), U1.B42 (VDD11), U1.B44 (VDD11), U5.1 (OUT), U5.18 (OUT), U5.19 (OUT), U5.20 (OUT)
+3.3V: C4.1, C8.2, C27.1, C42.1, C44.1, C47.1, C49.1, C51.1, D1.1 (K), F1.2, L3.1, L4.1, R1.2, R9.2, R10.2, R14.1, R15.1, U1.A3 (VDD33), U1.A34 (VDD33), U1.A39 (VDD33), U1.A47 (VDD33), U1.A51 (VDD33), U3.2 (EN), U3.3 (VIN), U5.5 (IN), U5.6 (IN), U5.7 (IN), U5.8 (IN), U5.10 (BIAS)
+5V: C9.1, C10.1, C11.2, D2.2 (A), R7.2, U3.6 (VOUT), U4.2 (IN_1), U4.3 (IN_2)
/PTXN: C2.1, J1.43 (PERp0/SATA-B-)
/PTXP: C1.1, J1.41 (PERn0/SATA-B+)
/TUSB7320/OSC_VSS: C6.1, C7.1, U1.B21 (VSS_OSC)
/TUSB7320/OSC_XI: C7.2, R3.1, U1.A23 (XI), Y1.3
/TUSB7320/OSC_XO: C6.2, R3.2, U1.A22 (XO), Y1.1
/UD1N: J2.3 (D-), L1.3
/UD1P: J2.5 (D+), L1.4
/UD2N: J2.4 (D-), L2.4
/UD2P: J2.6 (D+), L2.3
CLKREQZ: C5.2, J1.52 (CLKREQ#), U1.B36 (CLKREQ#)
DS1_VBUS: C14.1, C15.1, D4.1 (K), D6.2 (A), J2.1 (5V), U4.8 (OUT2)
DS2_VBUS: C12.1, C13.1, D3.1 (K), D5.2 (A), J2.2 (5V), U4.9 (OUT1)
GND: C3.1, C4.2, C5.1, C8.1, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.1, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, D1.2 (A), D3.2 (A), D4.2 (A), J1.3 (GND), J1.27 (GND), J1.33 (GND), J1.39 (GND), J1.45 (GND), J1.51 (GND), J1.57 (GND), J1.71 (GND), J1.73 (GND), J2.7 (GND), J2.8 (GND), R2.2, R5.1, R6.1, R8.1, R11.2, R12.2, R13.2, R17.1, U1.A2 (SDA), U1.A53 (GND), U1.B2 (SCL), U1.B20 (GND), U1.B32 (JTAG_RST#), U2.3 (GND), U2.8 (GND), U3.4 (GND)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
GRSTZ: C40.2, R15.2, U1.A15 (GRST#), U5.9 (PG)
unnamed: D2.1 (K), R11.1
unnamed: D5.1 (K), R12.1
unnamed: D6.1 (K), R13.1
unnamed: F1.1, J1.2 (3.3V), J1.4 (3.3V), J1.70 (3.3V), J1.72 (3.3V), J1.74 (3.3V)
unnamed: R1.1, R2.1, U1.A52 (AUX_DET)
unnamed: R5.2, U1.B14 (FREQSEL)
unnamed: R4.1, U1.A24 (R1EXT)
unnamed: R4.2, U1.B23 (R1EXTRTN)
unnamed: R6.2, R7.1, U3.1 (FB)
unnamed: L3.2, U3.5 (SW)
unnamed: R8.2, U4.7 (ILIM)
unnamed: C32.2, R14.2, U5.11 (EN)
unnamed: R16.2, R17.2, U5.16 (FB)
unnamed: C37.1, U5.15 (SS)
OVERCUR1Z: R10.1, U1.A36 (OVERCUR1#), U4.6 (~FAULT2)
OVERCUR2Z: R9.1, U1.A37 (OVERCUR2#), U4.10 (~FAULT1)
PCIE_REFCLKN: J1.53 (REFCLKn), U1.B41 (PCIE_REFCLKN)
PCIE_REFCLKP: J1.55 (REFCLKp), U1.A45 (PCIE_REFCLKP)
PCIE_RXN: J1.49 (PETp0/SATA-A+), U1.A42 (PCIE_RXN)
PCIE_RXP: J1.47 (PETn0/SATA-A-), U1.B39 (PCIE_RXP)
PCIE_TXN: C2.2, U1.A41 (PCIE_TXN)
PCIE_TXP: C1.2, U1.B38 (PCIE_TXP)
PERSTZ: J1.50 (PERST#), U1.A40 (PERST#)
PWRON1Z: U1.B33 (PWRON1#), U4.5 (EN2)
PWRON2Z: U1.B34 (PWRON2#), U4.4 (EN1)
USB_D1N: L1.2, U1.B18 (USB_DM_DN1), U2.4 (D2+), U2.7 (NC)
USB_D1P: L1.1, U1.A20 (USB_DP_DN1), U2.5 (D2-), U2.6 (NC)
USB_D2N: L2.1, U1.A13 (USB_DM_DN2), U2.2 (D1-), U2.9 (NC)
USB_D2P: L2.2, U1.B12 (USB_DP_DN2), U2.1 (D1+), U2.10 (NC)
VDDA: C41.1, C43.1, C45.1, C48.1, C50.1, C52.1, C53.1, C54.1, L4.2, U1.A19 (VDDA_3P3), U1.A21 (VDDA_3P3), U1.A25 (VDDA_3P3), U1.A44 (VDDA_3P3), U1.B4 (VDDA_3P3), U1.B11 (VDDA_3P3), U1.B22 (VDDA_3P3), U1.B26 (VDDA_3P3)
WAKEZ: C3.2, J1.54 (PEWAKE#), U1.B35 (WAKE#)

## Commit log (part)

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2025-10-15 init repo
2025-10-16 Uploading initial PCI2USB proejct files
2025-10-16 Updated schematics and board layout
2025-10-23 Fixed DRC Warnings and Errors
2025-10-27 Created schematics for 1.1V circuit
2025-10-29 Created 1.1V Circuit for USB Host IC
2025-10-29 Updated schematics for 1.1V circuit
2025-11-07 Fixed signal integrity for USB data lines
2025-11-13 Created schematics for TUSB7320 USB Controller
2025-11-17 Complete Schematics and BOM
2025-11-17 Placed additional information to board schematics
2025-11-20 updated BOM
2025-11-20 Updated PCB Design
2025-11-24 Updated PCB
2025-11-26 created final PCB design
2025-11-26 Fixed VIAs around screw holes
2025-11-26 Updated 3D models
2025-12-01 Cleaned custom libraries, fixed footprint and 3d models
2025-12-04 Redesigned PCB compliant with PCI and SS USB standards
2025-12-08 Fixed reversed 9 pin connector
2025-12-08 Fixed USB pair crosing with other net
2025-12-08 Updated 3D models and Logo
2025-12-08 Moved USB connector to acheive wider 5V traces
2025-12-08 removed temporary files
2025-12-08 fixed pdf schematics, removed temporary files
2025-12-08 Created all necessary production files
2026-03-02 Updated MPN for a few Capacitors
2026-03-02 Removed duplicated components in BOM
2026-03-27 Change parameters of board thickness
2026-03-27 Added more thermal relief points, and bigger power traces
2026-03-27 Updated all SMD footprints to not hand soldered versions
2026-03-27 the breakout holes were shrunk down
2026-03-27 generated new production files
2026-06-23 experiment to fit 15 thermal vias
