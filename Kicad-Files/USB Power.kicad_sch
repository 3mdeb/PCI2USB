File: Kicad-Files/USB Power.kicad_sch (KiCad schematic)
At the start: 30 parts, among them U1 TPS61023, U4 TPS2560

Commit message: Complete Schematics and BOM
Signed-off-by: Jakub Sobota <jakub.sobota@3mdeb.com>
Parts:
- removed D3: 4V/5A, Diode_SMD:D_SOD-523, symbol Diode:PTVS5V0Z1USK
- removed F1: 5A, Fuse:Fuse_0603_1608Metric_Pad1.05x0.95mm_HandSolder, symbol Device:Fuse_Small
- C10, C11, C9: value 0.1uF -> 0.1 μF; footprint (none) -> Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
- C12, C13: footprint (none) -> Capacitor_SMD:CP_Elec_6.3x5.9
- R15, R16, R17, R18, R19: footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
Connections:
- net +3.3V: now also C1.1, D1.2 (A), L1.1, U1.2 (EN), U1.3 (VIN)
Other:
- note added: "5V REGULATOR"
- note added: "DOWNSTREAM POWER SWITCH"
- company: 3mdeb Sp. z o.o -> 3mdeb Sp. z o.o    Jakub Sobota
- moved on the sheet: C1, C12, C13, C2, C3, D1, D2, D4, D6, D7, F2, L1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

Commit message: Updated 3D models
Signed-off-by: Jakub Sobota <jakub.sobota@3mdeb.com>
Changed lines of the file:
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@@
-	(wire
-		(pts
-			(xy 82.55 166.37) (xy 72.39 166.37)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
 	(wire
 		(pts
@@
 		)
 		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 72.39 166.37) (xy 82.55 166.37)
+		)
+		(stroke

Commit message: Cleaned custom libraries, fixed footprint and 3d models
Signed-off-by: Jakub Sobota <jakub.sobota@3mdeb.com>
Parts:
- removed D2: 6V/5A, Diode_SMD:D_SOD-523, symbol Diode:PTVS5V0Z1USK
- removed U1: TPS61023, DC-DC:TPS61023, symbol DC-DC Converter:TPS61023
- removed U4: TPS2560, Package_SON:VSON-10-1EP_3x3mm_P0.5mm_EP1.65x2.4mm_ThermalVias, symbol Interface_USB:TPS2560
- added D2: PJSD03TS-AU, PJSD0XTS-AU:PJSD0XTS-AU, symbol PJSD0XTS-AU:PJSD03TS-AU
- added U1: TPS61023DRLR, TPS61023:TPS61023DRLR, symbol TPS61023:TPS61023DRLR
- added U4: TPS2560DRC, TPS2560:TPS2560DRCT, symbol TPS2560:TPS2560DRCT
Connections:
- net +3.3V: now also U1.2 (EN), U1.3 (VIN)
- net +5V: now also U4.2 (IN_1), U4.3 (IN_2)
- net DS1_VBUS: now also U4.9 (OUT1)
- net DS2_VBUS: now also U4.8 (OUT2)
- net GND: now also D2.2 (A), U1.4 (GND), U4.1 (GND_1), U4.11 (GND_2), U4.12 (GND_3), U4.13 (GND_4), U4.14 (GND_5), U4.15 (GND_6); no longer C10.2, C11.2, C12.2, C13.2, R17.1
- net OVERCUR1Z: now also U4.10 (~{FAULT1})
- net OVERCUR2Z: now also U4.6 (~{FAULT2})
- net PWRON1Z: now also U4.4 (EN1)
- net PWRON2Z: now also U4.5 (EN2)
- net at L1.2: now also U1.5 (SW)
- net at R17.2: now also U4.7 (ILIM)
- net at R1.1, R2.2: now also U1.1 (FB)
- net at C2.2, C3.2, D4.2 (A)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: now also D2.1 (K), U1.6 (VOUT)
- new net: C10.2, C11.2, C12.2, C13.2, R17.1
Other:
- note added: "5V BOOST CONVERTER"
- note removed: "5V REGULATOR"
- moved on the sheet: C9, R15, R16, R17

Commit message: Redesigned PCB compliant with PCI and SS USB standards
Signed-off-by: Jakub Sobota <jakub.sobota@3mdeb.com>
Parts:
- removed D1: LED, LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder, symbol Device:LED
- removed R3: 680 Ohm, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, symbol Device:R_US
- added R29: 100 KOhm, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, symbol Device:R_US
- C1: value 10 μF -> 22 μF
- D2: value PJSD03TS-AU -> 6V/9V/5A
- R2: footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- renumbered U4 to U2
Connections:
- net +3.3V: now also C1.2, R29.1; no longer C1.1, U1.2 (EN)
- net GND: now also C1.1, C10.2, C11.2, C12.2, C13.2, R17.1; no longer C1.2
- new net: R29.2, U1.2 (EN)
